# Keil uVision project mini_prjct.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2124 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: lcd_present +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s rtc.c lcd.c kpm.c delay.c settings_valid.c adc.c pin_connect_block.c pr_main.c uart.c
